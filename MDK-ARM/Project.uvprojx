# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TIM1_PWM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\Inc;..\Drivers\BSP\PY32F002xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f002xx.s
    ../Drivers/CMSIS/Device/PY32F0xx/Source/: system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c key.c led.c
  group BSP/py32f002xx_Start_Kit
    ../Drivers/BSP/PY32F002xx_Start_Kit/: py32f002xx_Start_Kit.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
